## src/drivers/uavlas/Kconfig
```kconfig
menuconfig DRIVERS_UAVLAS
	bool "uavlas"
	default n
	---help---
		Enable support for uavlas
```
